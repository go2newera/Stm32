# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER\APP;..\FWlib\inc;..\CMSIS;..\SYSTEM\led;..\SYSTEM\valves;..\SYSTEM\usart;..\SYSTEM\exti;..\SYSTEM\adc;..\SYSTEM\sys;..\SYSTEM\iic;..\SYSTEM\spi
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/APP/: main.c
  group CMSIS
    ../CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/led/: led.c
    ../SYSTEM/valves/: valves.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/exti/: exti.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/sys/: SysTick.c
    ../SYSTEM/iic/: i2c.c
    ../SYSTEM/spi/: spi.c
  group Document
    ../Document/: Readme.txt
