# Keil uVision project demon.uvprojx, settings and files
target demon (ARM-ADS)
  device: STM32L051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: demon
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_dma.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_adc.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/User
    ../Src/: i2c.c main.c dma.c spi.c stm32l0xx_it.c iwdg.c usart.c gpio.c stm32l0xx_hal_msp.c adc.c
software components: CMSIS:CORE 4.1.0
